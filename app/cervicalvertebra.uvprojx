# Keil uVision project cervicalvertebra.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cervicalvertebra
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Library\Start;.\Library\common;.\Library\driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: AdcSample.c EMS.c EMS_Port.c Key.c LedMotor.c main.c NTCTempSample.c TimeHandler.c UartHandler.c util.c
  group Library
    ./Library/driver/src/: adc.c adt.c bt.c ddl.c dmac.c flash.c gpio.c interrupts_hc32l136.c lpm.c lpuart.c sysctrl.c timer3.c
  group Start
    ./Library/Start/: startup_hc32l136.s
  group Common
    ./Library/common/: system_hc32l136.c
software components: CMSIS:CORE 5.2.0
